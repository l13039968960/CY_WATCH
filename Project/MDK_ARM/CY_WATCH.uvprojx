# Keil uVision project CY_WATCH.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CY_WATCH +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=4 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: -Wno-padded -Wno-sign-conversion -Wno-implicit-int-conversion -Wno-declaration-after-statement -Wno-newline-eof -Wno-cast-qual -Wno-extra-semi-stmt -Wno-switch-enum -Wno-cast-align -Wno-disabled-macro-expansion -Wno-missing-variable-declarations -Wno-unreachable-code-return -Wno-assign-enum -Wno-unused-parameter -Wno-missing-prototypes -Wno-missing-noreturn -Wno-covered-switch-default -Wno-unused-function -Wno-comma -Wno-bad-function-cast -Wno-unreachable-code-break -Wno-unreachable-code -Wno-shorten-64-to-32 -Wno-format-nonliteral -fno-short-enums
  c include: ..\..\Core;..\..\Core\Inc;..\..\Core\system;..\..\Core\system\delay;..\..\Core\system\uart;..\..\Core\system\Rtc;..\..\Core\GPIO;..\..\Core\EXTI;..\..\Core\SPI;..\..\Core\IIC;..\..\Core\ADC;..\..\Driver\STM32F4xx_HAL_Driver\Inc;..\..\Driver\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\Driver\CMSIS\Device\ST\STM32F4xx\Include;..\..\Driver\CMSIS\Include;..\..\BSP;..\..\BSP\ST7789T3;..\..\BSP\CST816T;..\..\BSP\W25Q64;..\..\BSP\ADKEY;..\..\BSP\Nordic;..\..\Core\UART;..\..\MIddleWares\FatFS\ff16\source;..\..\MIddleWares\FatFS\port;..\..\MIddleWares;..\..\MIddleWares\LVGL;..\..\MIddleWares\LVGL\lvgl;..\..\MIddleWares\LVGL\port;..\..\MIddleWares\LVGL\assets\fonts;..\..\MIddleWares\FreeRTOS;..\..\MIddleWares\FreeRTOS\include;..\..\MIddleWares\FreeRTOS\portable\GCC\ARM_CM4F;..\..\MIddleWares\FreeRTOS\CMSIS_RTOS_V2;..\..\MIddleWares\EasyAPP;..\..\MIddleWares\EasyAPP\inc;..\..\MIddleWares\EasyAPP\src;..\..\MIddleWares\EasyAPP\port;..\..\APP;..\..\APP\APP\DataModel;..\..\APP\Service\fatfs;..\..\APP\Service\fatfs\adapter;..\..\APP\Service\adkey;..\..\APP\Service\adkey\adapter;..\..\APP\Service\nordic;..\..\APP\Service\nordic\adapter;..\..\APP\Service\lvgl;..\..\APP\Service\lvgl\adapter;..\..\APP\Service\lvgl\ui;..\..\APP\Service\lvgl\ui_manger;..\..\BSP\MPU6050;..\..\BSP\MAX30102;..\..\BSP\AHT21;..\..\BSP\AT24C02;..\..\BSP\AT24C02\adapter;..\..\APP\Service\attitude;..\..\APP\Service\attitude\adapter;..\..\APP\Service\attitude\ServiceFunction;..\..\APP\Service\heartrate;..\..\APP\Service\humiture;..\..\APP\Service\humiture\adapter;..\..\APP\Service\heartrate\adapter;..\..\APP\Service\heartrate\ServiceFunction
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Core
    ../../Core/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c system_stm32f4xx.c
  group System
    ../../Core/system/delay/: delay.c
    ../../Core/system/uart/: uart.c
    ../../Core/system/Rtc/: cywatch_rtc.c
    ../../Core/system/rtstats/: rtstats.c
    ../../Core/system/log/: cywatch_log.c
  group Core/GPIO
    ../../Core/GPIO/: gpio_hal.c
  group Core/EXTI
    ../../Core/EXTI/: exti_hal.c
  group Core/SPI
    ../../Core/SPI/: spi_hal.c
  group Core/IIC
    ../../Core/IIC/: iic_hal.c
  group Core/ADC
    ../../Core/ADC/: adc_hal.c
  group Core/UART
    ../../Core/UART/: uart_hal.c
  group Startup
    ../../Driver/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
  group HAL_Driver
    ../../Driver/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_exti.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group OS/FreeRTOS
    ../../MIddleWares/FreeRTOS/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
    ../../MIddleWares/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
    ../../MIddleWares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../MIddleWares/FreeRTOS/CMSIS_RTOS_V2/: cmsis_os2.c
  group LVGL/src
    ../../MIddleWares/LVGL/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../../MIddleWares/LVGL/lvgl/src/display/: lv_display.c
    ../../MIddleWares/LVGL/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../../MIddleWares/LVGL/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../../MIddleWares/LVGL/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_nema_gfx_path.c
    ../../MIddleWares/LVGL/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../../MIddleWares/LVGL/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../../MIddleWares/LVGL/lvgl/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c
    ../../MIddleWares/LVGL/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../../MIddleWares/LVGL/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../../MIddleWares/LVGL/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../../MIddleWares/LVGL/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../../MIddleWares/LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../../MIddleWares/LVGL/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/display/drm/: lv_linux_drm.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/display/ft81x/: lv_ft81x.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/display/ili9341/: lv_ili9341.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/display/st7735/: lv_st7735.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/display/st7789/: lv_st7789.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/display/st7796/: lv_st7796.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/evdev/: lv_evdev.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/glfw/: lv_glfw_window.c lv_opengles_debug.c lv_opengles_driver.c lv_opengles_texture.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/qnx/: lv_qnx.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c lv_wl_cache.c lv_wl_dmabuf.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_pointer_axis.c lv_wl_seat.c lv_wl_shell.c lv_wl_shm.c lv_wl_touch.c lv_wl_window.c lv_wl_window_decorations.c lv_wl_xdg_shell.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../../MIddleWares/LVGL/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ../../MIddleWares/LVGL/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../MIddleWares/LVGL/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../../MIddleWares/LVGL/lvgl/src/layouts/flex/: lv_flex.c
    ../../MIddleWares/LVGL/lvgl/src/layouts/grid/: lv_grid.c
    ../../MIddleWares/LVGL/lvgl/src/layouts/: lv_layout.c
    ../../MIddleWares/LVGL/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../../MIddleWares/LVGL/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../../MIddleWares/LVGL/lvgl/src/libs/bmp/: lv_bmp.c
    ../../MIddleWares/LVGL/lvgl/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    ../../MIddleWares/LVGL/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../../MIddleWares/LVGL/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../../MIddleWares/LVGL/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../../MIddleWares/LVGL/lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ../../MIddleWares/LVGL/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../../MIddleWares/LVGL/lvgl/src/libs/libpng/: lv_libpng.c
    ../../MIddleWares/LVGL/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../../MIddleWares/LVGL/lvgl/src/libs/lz4/: lz4.c
    ../../MIddleWares/LVGL/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../MIddleWares/LVGL/lvgl/src/libs/rle/: lv_rle.c
    ../../MIddleWares/LVGL/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../../MIddleWares/LVGL/lvgl/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../../MIddleWares/LVGL/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../MIddleWares/LVGL/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../../MIddleWares/LVGL/lvgl/src/: lv_init.c
    ../../MIddleWares/LVGL/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c
    ../../MIddleWares/LVGL/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../../MIddleWares/LVGL/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../../MIddleWares/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../../MIddleWares/LVGL/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../../MIddleWares/LVGL/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../../MIddleWares/LVGL/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../../MIddleWares/LVGL/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../MIddleWares/LVGL/lvgl/src/others/gridnav/: lv_gridnav.c
    ../../MIddleWares/LVGL/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../../MIddleWares/LVGL/lvgl/src/others/imgfont/: lv_imgfont.c
    ../../MIddleWares/LVGL/lvgl/src/others/monkey/: lv_monkey.c
    ../../MIddleWares/LVGL/lvgl/src/others/observer/: lv_observer.c
    ../../MIddleWares/LVGL/lvgl/src/others/snapshot/: lv_snapshot.c
    ../../MIddleWares/LVGL/lvgl/src/others/sysmon/: lv_sysmon.c
    ../../MIddleWares/LVGL/lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../../MIddleWares/LVGL/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../../MIddleWares/LVGL/lvgl/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_parser.c lv_xml_style.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
    ../../MIddleWares/LVGL/lvgl/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_event_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
    ../../MIddleWares/LVGL/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../../MIddleWares/LVGL/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../../MIddleWares/LVGL/lvgl/src/stdlib/: lv_mem.c
    ../../MIddleWares/LVGL/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../../MIddleWares/LVGL/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../../MIddleWares/LVGL/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../../MIddleWares/LVGL/lvgl/src/themes/default/: lv_theme_default.c
    ../../MIddleWares/LVGL/lvgl/src/themes/: lv_theme.c
    ../../MIddleWares/LVGL/lvgl/src/themes/mono/: lv_theme_mono.c
    ../../MIddleWares/LVGL/lvgl/src/themes/simple/: lv_theme_simple.c
    ../../MIddleWares/LVGL/lvgl/src/tick/: lv_tick.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/animimage/: lv_animimage.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/arc/: lv_arc.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/bar/: lv_bar.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/button/: lv_button.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/canvas/: lv_canvas.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/chart/: lv_chart.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/image/: lv_image.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/label/: lv_label.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/led/: lv_led.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/line/: lv_line.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/list/: lv_list.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/lottie/: lv_lottie.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/menu/: lv_menu.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/roller/: lv_roller.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/scale/: lv_scale.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/slider/: lv_slider.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/span/: lv_span.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/spinner/: lv_spinner.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/switch/: lv_switch.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/table/: lv_table.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/tabview/: lv_tabview.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/textarea/: lv_textarea.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/tileview/: lv_tileview.c
    ../../MIddleWares/LVGL/lvgl/src/widgets/win/: lv_win.c
  group LVGL/port
    ../../MIddleWares/LVGL/port/: lv_port_disp.c lv_port_indev.c
  group LVGL/assets
    ../../MIddleWares/LVGL/assets/fonts/: lv_font_alibaba_puhuiti_14.c lv_font_montserrat_regular_16.c lv_font_montserrat_regular_20.c
    ../../MIddleWares/LVGL/assets/image/: icon_heart_18x18_RGB565A8_NONE.c icon_steps_18x18_RGB565A8_NONE.c icon_flame_18x18_RGB565A8_NONE.c
  group Bsp
    ../../BSP/ST7789T3/: cywatch_bsp_st7789t3_driver.c
    ../../BSP/CST816T/: cywatch_bsp_cst816t_driver.c
    ../../BSP/W25Q64/: cywatch_bsp_w25q64_driver.c
    ../../BSP/ADKEY/: cywatch_bsp_adkey_driver.c
    ../../BSP/Nordic/: cywatch_bsp_nordic_driver.c
    ../../BSP/MPU6050/: cywatch_bsp_mpu6050_driver.c
    ../../BSP/MAX30102/: cywatch_bsp_max30102_driver.c
    ../../BSP/AHT21/: cywatch_bsp_aht21_driver.c
    ../../BSP/AT24C02/: cywatch_bsp_at24c02_driver.c
  group FatFS/source
    ../../MIddleWares/FatFS/ff16/source/: ff.c ffunicode.c
  group FatFS/port
    ../../MIddleWares/FatFS/port/: cywatch_fatfs_diskio.c cywatch_fatfs_os.c
  group Service/fatfs
    ../../APP/Service/fatfs/: cywatch_service_fatfs.c
  group Service/fatfs/adapter
    ../../APP/Service/fatfs/adapter/: cywatch_adapter_w25q64.c
  group Service/adkey
    ../../APP/Service/adkey/: cywatch_service_key.c
  group Service/adkey/adapter
    ../../APP/Service/adkey/adapter/: cywatch_adapter_adkey.c
  group Service/nordic
    ../../APP/Service/nordic/: cywatch_service_nordicprotocol.c
  group Service/nordic/adapter
    ../../APP/Service/nordic/adapter/: cywatch_adapter_nordic.c
  group APP/EasyAPP
    ../../MIddleWares/EasyAPP/src/: easyapp_core.c easyapp_event.c easyapp_page.c
    ../../MIddleWares/EasyAPP/port/: easyapp_port.c
  group App/DataModel
    ../../APP/APP/DataModel/: cywatch_app_datamodel.c
  group Service/lvgl
    ../../APP/Service/lvgl/: cywatch_service_lvgl.c
  group Service/lvgl/adapter
    ../../APP/Service/lvgl/adapter/: cywatch_adapter_disp.c cywatch_adapter_indev.c
  group Service/lvgl/ui_manger
    ../../APP/Service/lvgl/ui_manger/: PageMem.c
  group Service/lvgl/ui
    ../../APP/Service/lvgl/ui/: lv_watch_ui.c lv_watch_page_home.c lv_watch_page_menu.c lv_watch_page_heart.c lv_watch_page_spo2.c lv_watch_page_ota.c
  group Service/attitude
    ../../APP/Service/attitude/: cywatch_service_AttitudeCalculation.c
  group Service/attitude/adapter
    ../../APP/Service/attitude/adapter/: cywatch_adapter_mpu6050.c
  group Service/attitude/ServiceFunction
    ../../APP/Service/attitude/ServiceFunction/: AttitudeCalculation.c
  group Service/heartrate
    ../../APP/Service/heartrate/: cywatch_service_HeartRate.c
  group Service/heartrate/adapter
    ../../APP/Service/heartrate/adapter/: cywatch_adapter_max30102.c
  group Service/heartrate/ServiceFunction
    ../../APP/Service/heartrate/ServiceFunction/: HeartRate.c SpO2.c
  group Service/humiture
    ../../APP/Service/humiture/: cywatch_service_humiture.c
  group Service/humiture/adapter
    ../../APP/Service/humiture/adapter/: cywatch_adapter_aht21.c
  group Bsp/AT24C02/adapter
    ../../BSP/AT24C02/adapter/: cywatch_adapter_at24c02.c
